# Repository nakaaka/KiCad

## KiCad design MD_A3941_v0_EVB/MD_A3941_v0_EVB.kicad_pcb

Parts:
C1, C3, C4: 330u; CP_Elec_10x10
C5, C9, C13, C15, C16: 0.1u; C_0603_1608Metric
C6, C7, C8: 1u; C_0603_1608Metric
C10: 22u; C_0603_1608Metric
C11: 470n; C_0603_1608Metric
C12, C14: 100p; C_0603_1608Metric
D1, D5, D6, D7: GREEN; LED_0603_1608Metric
D3, D4: RED; LED_0603_1608Metric
IC1: A3941KLPTR-T; A3944KLPTRT; Manufacturer_Part_Number A3941KLPTR-T
J1: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Horizontal
J2: Conn_02x01; AMASS_XT60-M_1x02_P7.20mm_Vertical
J3, J5, J6, J13: XT60; AMASS_XT60-M_1x02_P7.20mm_Vertical
J4: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
J7, J8, J9, J11, J12, J15, J16, J17: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
J10, J14: Conn_01x06_Pin; PinSocket_1x06_P2.54mm_Vertical
J18, J19: Conn_01x01_Pin; PinSocket_1x01_P2.54mm_Vertical
Q1, Q2, Q3, Q4: BSC031N06NS3G; Infineon_PG-TDSON-8_6.15x5.15mm
Q5, Q6, Q7, Q8: TK100E06N; TO-220-3_Horizontal_TabDown
R1, R7, R9, R10, R13: 10k; R_0603_1608Metric
R3, R8, R12: 22k; R_0603_1608Metric
R4, R6, R11: 100k; R_0603_1608Metric
R5: 3.3k; R_0603_1608Metric
R14, R15, R17, R18: 22; R_0603_1608Metric
R16: 5m; R_2512_6332Metric
R19, R20, R21: 1k; R_0603_1608Metric
U1: 74AHC1G08; SOT-23-5
U2: TC7WH74; SSOP-8_2.95x2.8mm_P0.65mm
U3: NJM2903; TSSOP-8_4.4x3mm_P0.65mm
U4: INA180A1; SOT-23-5

Connections:
1-24V: J1.1, J1.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J1.9, J1.10, J1.11, J1.12, J1.13, J1.14, J1.15, J1.16, J1.17, J1.18, J3.2
1-GND: J1.19, J1.20, J1.21, J1.22, J1.23, J1.24, J1.25, J1.26, J1.27, J1.28, J1.29, J1.30, J1.31, J1.32, J1.33, J1.34, J1.35, J1.36, J1.38, J3.1, J4.2
1-PHASE: J1.40, J4.4
1-PWM: J1.39, J4.3
1-VCC: J1.37, J4.1
2-24V: C1.1, C3.1, C4.1, C5.1, D1.2 (A), J5.2, J6.2, J7.2
2-GND: C1.2, C3.2, C4.2, C5.2, J5.1, J6.1, J7.1, R1.2
3-GND: C16.2, J8.1, J9.1, R21.2
3-VCC: C16.1, D7.2 (A), J8.2, J9.2
4-24V: C8.1, C9.1, IC1.1 (VDRAIN), IC1.13 (VBB_1), IC1.14 (VBB_2), J11.2, R8.1
4-GHA: IC1.10 (GHA), J10.3
4-GHB: IC1.5 (GHB), J10.4
4-GLA: IC1.12 (GLA), J10.1
4-GLB: IC1.3 (GLB), J10.6
4-GND: C8.2, C9.2, C10.2, C13.2, IC1.2 (LSS), IC1.17 (GND_1), IC1.18 (GND_2), IC1.29 (EP), J11.1, R5.2, R20.2
4-PHASE: D6.2 (A), IC1.19 (PHASE), J12.1
4-PMWH: IC1.23 (PWMH), J12.2
4-SA: C7.2, IC1.11 (SA), J10.2
4-SB: C6.1, IC1.4 (SB), J10.5
5-24V: J13.2, Q1.5 (D), Q3.5 (D), Q5.2 (D), Q8.2 (D)
5-GHA: J14.3, R14.1
5-GHB: J14.4, R17.2
5-GLA: J14.1, R15.1
5-GLB: J14.6, R18.2
5-GND: J13.1, J16.1, R16.2
5-SA: J2.2, J14.2, Q1.1 (S), Q1.2, Q1.3, Q2.5 (D), Q5.3 (S), Q6.2 (D)
5-SB: J2.1, J14.5, Q3.1 (S), Q3.2, Q3.3, Q4.5 (D), Q7.2 (D), Q8.3 (S)
5-ShuntRP: J16.2, Q2.1 (S), Q2.2, Q2.3, Q4.1 (S), Q4.2, Q4.3, Q6.3 (S), Q7.3 (S), R16.1
6-GND: C12.2, C14.2, C15.1, J15.1, R3.2, R12.1, R19.2, U1.5 (VCC), U2.4 (GND), U3.4 (V-), U4.2 (GND)
6-PMWH: J19.1, U1.4
6-PWM: D5.2 (A), J18.1, R3.1, U1.1, U2.1 (C)
6-ShuntRM: J17.1, U4.4 (-)
6-ShuntRP: J17.2, U4.3 (+)
6-VCC: C15.2, J15.2, R11.2, U1.3 (GND), U2.2 (D), U2.7 (~PRE), U2.8 (VCC), U3.8 (V+), U4.5 (V+)
unnamed: D1.1 (K), R1.1
unnamed: C13.1, D3.2 (A), D4.2 (A), IC1.20 (V5), IC1.28 (VDSTH), R4.1, R6.1
unnamed: D3.1 (K), R9.1
unnamed: D4.1 (K), R10.1
unnamed: D5.1 (K), R19.1
unnamed: D6.1 (K), R20.1
unnamed: D7.1 (K), R21.1
unnamed: C7.1, IC1.9 (CA)
unnamed: C6.2, IC1.6 (CB)
unnamed: C11.1, IC1.16 (CP1)
unnamed: C11.2, IC1.15 (CP2)
unnamed: IC1.25 (FF1), R9.2
unnamed: IC1.26 (FF2), R10.2
unnamed: IC1.22 (PWML), R6.2
unnamed: IC1.27 (RDEAD), R5.1
unnamed: IC1.24 (RESET), R8.2
unnamed: IC1.21 (SR), R4.2
unnamed: C10.1, IC1.7 (VREG_1), IC1.8 (VREG_2)
unnamed: Q1.4 (G), Q5.1 (G), R14.2
unnamed: Q2.4 (G), Q6.1 (G), R15.2
unnamed: Q3.4 (G), Q8.1 (G), R17.1
unnamed: Q4.4 (G), Q7.1 (G), R18.1
unnamed: R7.2, U3.7
unnamed: R13.2, U4.1
unnamed: U1.2, U2.5 (Q)
unnamed: C12.1, R7.1, U2.6 (~CLR)
unnamed: R11.1, R12.2, U3.5 (+)
unnamed: C14.1, R13.1, U3.6 (-)

Notes on the sheet:
5.Hブリッジ
5x22/122=~0.9->9Aクリッピング
6.電流制限回路
2.24V安定化
3.Vcc安定化
4.ゲート駆動
1.ピンヘッダ

Board: 2 copper layers, 100.0 x 100.0 mm, 73 parts (0 on the bottom side), 62 nets.

## KiCad design ABU2023_Hab_board_ver4.1_5port/ABU2023_Hab_board_ver4.1.kicad_pcb

Parts:
J1, J6: RJ45_LPJK7001AGNL; LPJK7001AGNL; LCSC x
J2, J3: XA_12V; JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal; LCSC x
J4: PW24V_XT60; AMASS_XT60-F_1x02_P7.20mm_Vertical; LCSC x
J5: PW24V_XT60; AMASS_XT60-M_1x02_P7.20mm_Vertical; LCSC x
R25: 13k; R_0603_1608Metric; LCSC C22797
R26: 10k; R_0603_1608Metric; LCSC C25804
SW1: SW_Push; SW_PUSH_6mm; LCSC x

Connections:
+12V: J2.1, J3.1, R25.1; also elsewhere on the board
+24V: J4.2, J5.2; also elsewhere on the board
/RESET: R26.1, SW1.2; also elsewhere on the board
/connecter_1/RXAN: J1.6 (RD-); also elsewhere on the board
/connecter_1/RXAP: J1.4 (RD+); also elsewhere on the board
/connecter_1/TXAN: J1.10 (TD-); also elsewhere on the board
/connecter_1/TXAP: J1.12 (TD+); also elsewhere on the board
/connecter_1/VDD33TXRX1: J1.5 (RCT), J1.11 (TCT); also elsewhere on the board
/connecter_5/RXBN: J6.6 (RD-); also elsewhere on the board
/connecter_5/RXBP: J6.4 (RD+); also elsewhere on the board
/connecter_5/TXBN: J6.10 (TD-); also elsewhere on the board
/connecter_5/TXBP: J6.12 (TD+); also elsewhere on the board
/connecter_5/VDD33TXRX2: J6.5 (RCT), J6.11 (TCT); also elsewhere on the board
GND: J1.8 (GND), J2.2, J3.2, J6.8 (GND), R26.2; also elsewhere on the board
GNDPWR: J4.1, J5.1; also elsewhere on the board
unnamed: R25.2, SW1.1

Parts:
J11: JL_01x15; JST_JL_15JL-BT-E; LCSC x
J12: PW24V_XT60; AMASS_XT60-M_1x02_P7.20mm_Vertical; LCSC x

Connections:
+12V: J11.2; also elsewhere on the board
+24V: J12.2; also elsewhere on the board
/CAN_H: J11.4; also elsewhere on the board
/CAN_L: J11.5; also elsewhere on the board
/RESET: J11.3; also elsewhere on the board
/RXN_23: J11.9; also elsewhere on the board
/RXP_23: J11.10; also elsewhere on the board
/TXN_23: J11.7; also elsewhere on the board
/TXP_23: J11.8; also elsewhere on the board
/TXRXCT: J11.6; also elsewhere on the board
/connecter_3/RXBN: J11.12; also elsewhere on the board
/connecter_3/RXBP: J11.11; also elsewhere on the board
/connecter_3/TXBN: J11.14; also elsewhere on the board
/connecter_3/TXBP: J11.13; also elsewhere on the board
/connecter_3/VDD33TXRX2: J11.15; also elsewhere on the board
GND: J11.1; also elsewhere on the board
GNDPWR: J12.1; also elsewhere on the board

Parts of its further copies:
J7, J9, J13, J15: JL_01x15; JST_JL_15JL-BT-E; LCSC x
J8, J10, J14, J16: PW24V_XT60; AMASS_XT60-M_1x02_P7.20mm_Vertical; LCSC x

Connections of its further copies:
+12V: J7.2, J9.2, J13.2, J15.2; also elsewhere on the board
+24V: J8.2, J10.2, J14.2, J16.2; also elsewhere on the board
/CAN_H: J7.4, J9.4, J13.4, J15.4; also elsewhere on the board
/CAN_L: J7.5, J9.5, J13.5, J15.5; also elsewhere on the board
/RESET: J7.3, J9.3, J13.3, J15.3; also elsewhere on the board
/connecter_1/RXAN: J7.9; also elsewhere on the board
/connecter_1/RXAP: J7.10; also elsewhere on the board
/connecter_1/RXBN: J7.12; also elsewhere on the board
/connecter_1/RXBP: J7.11; also elsewhere on the board
/connecter_1/TXAN: J7.7; also elsewhere on the board
/connecter_1/TXAP: J7.8; also elsewhere on the board
/connecter_1/TXBN: J7.14; also elsewhere on the board
/connecter_1/TXBP: J7.13; also elsewhere on the board
/connecter_1/VDD33TXRX1: J7.6; also elsewhere on the board
/connecter_1/VDD33TXRX2: J7.15; also elsewhere on the board
/connecter_2/RXAN: J9.9; also elsewhere on the board
/connecter_2/RXAP: J9.10; also elsewhere on the board
/connecter_2/RXBN: J9.12; also elsewhere on the board
/connecter_2/RXBP: J9.11; also elsewhere on the board
/connecter_2/TXAN: J9.7; also elsewhere on the board
/connecter_2/TXAP: J9.8; also elsewhere on the board
/connecter_2/TXBN: J9.14; also elsewhere on the board
/connecter_2/TXBP: J9.13; also elsewhere on the board
/connecter_2/VDD33TXRX1: J9.6; also elsewhere on the board
/connecter_2/VDD33TXRX2: J9.15; also elsewhere on the board
/connecter_4/RXAN: J13.9; also elsewhere on the board
/connecter_4/RXAP: J13.10; also elsewhere on the board
/connecter_4/RXBN: J13.12; also elsewhere on the board
/connecter_4/RXBP: J13.11; also elsewhere on the board
/connecter_4/TXAN: J13.7; also elsewhere on the board
/connecter_4/TXAP: J13.8; also elsewhere on the board
/connecter_4/TXBN: J13.14; also elsewhere on the board
/connecter_4/TXBP: J13.13; also elsewhere on the board
/connecter_4/VDD33TXRX1: J13.6; also elsewhere on the board
/connecter_4/VDD33TXRX2: J13.15; also elsewhere on the board
/connecter_5/RXAN: J15.9; also elsewhere on the board
/connecter_5/RXAP: J15.10; also elsewhere on the board
/connecter_5/RXBN: J15.12; also elsewhere on the board
/connecter_5/RXBP: J15.11; also elsewhere on the board
/connecter_5/TXAN: J15.7; also elsewhere on the board
/connecter_5/TXAP: J15.8; also elsewhere on the board
/connecter_5/TXBN: J15.14; also elsewhere on the board
/connecter_5/TXBP: J15.13; also elsewhere on the board
/connecter_5/VDD33TXRX1: J15.6; also elsewhere on the board
/connecter_5/VDD33TXRX2: J15.15; also elsewhere on the board
GND: J7.1, J9.1, J13.1, J15.1; also elsewhere on the board
GNDPWR: J8.1, J10.1, J14.1, J16.1; also elsewhere on the board

Parts:
C3, C6: 1000p; C_0603_1608Metric; LCSC C1588
L5, L6: ACM2012-361-2P; LCSC C404377
R17, R18, R19, R20, R21, R22, R23, R24: 75; R_0603_1608Metric; LCSC C4275
T9, T10, T11, T12: ALT4532M-201-T001_1; ALT4532M; Manufacturer_Part_Number ALT4532M-201-T001; Mouser Part Number 810-ALT4532M201-T001

Connections:
/connecter_3/RXBN: T10.2; also elsewhere on the board
/connecter_3/RXBP: T10.1; also elsewhere on the board
/connecter_3/TXBN: T9.2; also elsewhere on the board
/connecter_3/TXBP: T9.1; also elsewhere on the board
/connecter_3/VDD33TXRX2: T9.6, T10.6; also elsewhere on the board
/connecter_4/RXAN: T12.2; also elsewhere on the board
/connecter_4/RXAP: T12.1; also elsewhere on the board
/connecter_4/TXAN: T11.2; also elsewhere on the board
/connecter_4/TXAP: T11.1; also elsewhere on the board
/connecter_4/VDD33TXRX1: T11.6, T12.6; also elsewhere on the board
GND: C3.2, C6.2; also elsewhere on the board
unnamed: C3.1, R17.2, R18.2, R19.1, R20.1
unnamed: C6.1, R21.2, R22.2, R23.1, R24.1
unnamed: L5.1, T9.5
unnamed: L5.2, T9.4
unnamed: L5.3, T11.4
unnamed: L5.4, T11.5
unnamed: L6.1, T10.5
unnamed: L6.2, T10.4
unnamed: L6.3, T12.4
unnamed: L6.4, T12.5
unnamed: R17.1, T9.3
unnamed: R18.1, T10.3
unnamed: R19.2, R21.1
unnamed: R20.2, R22.1
unnamed: R23.2, T11.3
unnamed: R24.2, T12.3

Parts of its further copies:
C1, C2, C4, C5, C7, C8: 1000p; C_0603_1608Metric; LCSC C1588
L1, L2, L3, L4, L7, L8: ACM2012-361-2P; LCSC C404377
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R27, R28, R29, R30, R31, R32, R33, R34: 75; R_0603_1608Metric; LCSC C4275
T1, T2, T3, T4, T5, T6, T7, T8, T13, T14, T15, T16: ALT4532M-201-T001_1; ALT4532M; Manufacturer_Part_Number ALT4532M-201-T001; Mouser Part Number 810-ALT4532M201-T001

Connections of its further copies:
/RXN_23: T8.2; also elsewhere on the board
/RXP_23: T8.1; also elsewhere on the board
/TXN_23: T7.2; also elsewhere on the board
/TXP_23: T7.1; also elsewhere on the board
/TXRXCT: T7.6, T8.6; also elsewhere on the board
/connecter_1/RXBN: T2.2; also elsewhere on the board
/connecter_1/RXBP: T2.1; also elsewhere on the board
/connecter_1/TXBN: T1.2; also elsewhere on the board
/connecter_1/TXBP: T1.1; also elsewhere on the board
/connecter_1/VDD33TXRX2: T1.6, T2.6; also elsewhere on the board
/connecter_2/RXAN: T4.2; also elsewhere on the board
/connecter_2/RXAP: T4.1; also elsewhere on the board
/connecter_2/RXBN: T6.2; also elsewhere on the board
/connecter_2/RXBP: T6.1; also elsewhere on the board
/connecter_2/TXAN: T3.2; also elsewhere on the board
/connecter_2/TXAP: T3.1; also elsewhere on the board
/connecter_2/TXBN: T5.2; also elsewhere on the board
/connecter_2/TXBP: T5.1; also elsewhere on the board
/connecter_2/VDD33TXRX1: T3.6, T4.6; also elsewhere on the board
/connecter_2/VDD33TXRX2: T5.6, T6.6; also elsewhere on the board
/connecter_4/RXBN: T14.2; also elsewhere on the board
/connecter_4/RXBP: T14.1; also elsewhere on the board
/connecter_4/TXBN: T13.2; also elsewhere on the board
/connecter_4/TXBP: T13.1; also elsewhere on the board
/connecter_4/VDD33TXRX2: T13.6, T14.6; also elsewhere on the board
/connecter_5/RXAN: T16.2; also elsewhere on the board
/connecter_5/RXAP: T16.1; also elsewhere on the board
/connecter_5/TXAN: T15.2; also elsewhere on the board
/connecter_5/TXAP: T15.1; also elsewhere on the board
/connecter_5/VDD33TXRX1: T15.6, T16.6; also elsewhere on the board
GND: C1.2, C2.2, C4.2, C5.2, C7.2, C8.2; also elsewhere on the board
unnamed: C1.1, R1.2, R2.2, R3.1, R4.1
unnamed: C2.1, R9.2, R10.2, R11.1, R12.1
unnamed: C4.1, R5.2, R6.2, R7.1, R8.1
unnamed: C5.1, R13.2, R14.2, R15.1, R16.1
unnamed: C7.1, R27.2, R28.2, R29.1, R30.1
unnamed: C8.1, R31.2, R32.2, R33.1, R34.1
unnamed: L1.1, T1.5
unnamed: L1.2, T1.4
unnamed: L1.3, T3.4
unnamed: L1.4, T3.5
unnamed: L2.1, T2.5
unnamed: L2.2, T2.4
unnamed: L2.3, T4.4
unnamed: L2.4, T4.5
unnamed: L3.1, T5.5
unnamed: L3.2, T5.4
unnamed: L3.3, T7.4
unnamed: L3.4, T7.5
unnamed: L4.1, T6.5
unnamed: L4.2, T6.4
unnamed: L4.3, T8.4
unnamed: L4.4, T8.5
unnamed: L7.1, T13.5
unnamed: L7.2, T13.4
unnamed: L7.3, T15.4
unnamed: L7.4, T15.5
unnamed: L8.1, T14.5
unnamed: L8.2, T14.4
unnamed: L8.3, T16.4
unnamed: L8.4, T16.5
unnamed: R1.1, T1.3
unnamed: R2.1, T2.3
unnamed: R3.2, R5.1
unnamed: R4.2, R6.1
unnamed: R7.2, T3.3
unnamed: R8.2, T4.3
unnamed: R9.1, T5.3
unnamed: R10.1, T6.3
unnamed: R11.2, R13.1
unnamed: R12.2, R14.1
unnamed: R15.2, T7.3
unnamed: R16.2, T8.3
unnamed: R27.1, T13.3
unnamed: R28.1, T14.3
unnamed: R29.2, R31.1
unnamed: R30.2, R32.1
unnamed: R33.2, T15.3
unnamed: R34.2, T16.3

Board: 4 copper layers, 120.0 x 80.0 mm, 87 parts (68 on the bottom side), 122 nets.

Other parts of the board:
REF1, REF1#2, REF1#3, REF1#4: MountingHole_3.2mm_M3

File ABU2023_Hab_board_ver4.1_5port/jlcpcb/production_files/BOM-ABU2023_Hab_board_ver4.csv:

Comment,Designator,Footprint,LCSC
1000p,"C1,C2,C3,C4,C5,C6,C7,C8",C_0603_1608Metric,C1588
13k,R25,R_0603_1608Metric,C22797
10k,R26,R_0603_1608Metric,C25804
ACM2012-361-2P,"L1,L2,L3,L4,L5,L6,L7,L8",ACM2012-361-2P,C404377
75,"R1,R10,R11,R12,R13,R14,R15,R16,R17,R18,R19,R2,R20,R21,R22,R23,R24,R27,R28,R29,R3,R30,R31,R32,R33,R34,R4,R5,R6,R7,R8,R9",R_0603_1608Metric,C4275
ALT4532M-201-T001_1,T16,ALT4532M,
ALT4532M-201-T001_1,T13,ALT4532M,
ALT4532M-201-T001_1,T15,ALT4532M,
ALT4532M-201-T001_1,T14,ALT4532M,
PW24V_XT60,J16,AMASS_XT60-M_1x02_P7.20mm_Vertical,
JL_01x15,J15,JST_JL_15JL-BT-E,
JL_01x15,J13,JST_JL_15JL-BT-E,
PW24V_XT60,J10,AMASS_XT60-M_1x02_P7.20mm_Vertical,
PW24V_XT60,J12,AMASS_XT60-M_1x02_P7.20mm_Vertical,
XA_12V,J3,JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal,
PW24V_XT60,J8,AMASS_XT60-M_1x02_P7.20mm_Vertical,
PW24V_XT60,J5,AMASS_XT60-M_1x02_P7.20mm_Vertical,
SW_Push,SW1,SW_PUSH_6mm,
XA_12V,J2,JST_XA_S02B-XASK-1_1x02_P2.50mm_Horizontal,
JL_01x15,J7,JST_JL_15JL-BT-E,
PW24V_XT60,J4,AMASS_XT60-F_1x02_P7.20mm_Vertical,
JL_01x15,J11,JST_JL_15JL-BT-E,
PW24V_XT60,J14,AMASS_XT60-M_1x02_P7.20mm_Vertical,
JL_01x15,J9,JST_JL_15JL-BT-E,
ALT4532M-201-T001_1,T12,ALT4532M,
ALT4532M-201-T001_1,T3,ALT4532M,
ALT4532M-201-T001_1,T1,ALT4532M,
ALT4532M-201-T001_1,T2,ALT4532M,
ALT4532M-201-T001_1,T7,ALT4532M,
ALT4532M-201-T001_1,T6,ALT4532M,
ALT4532M-201-T001_1,T5,ALT4532M,
ALT4532M-201-T001_1,T9,ALT4532M,
RJ45_LPJK7001AGNL,J6,LPJK7001AGNL,
ALT4532M-201-T001_1,T8,ALT4532M,
ALT4532M-201-T001_1,T10,ALT4532M,
ALT4532M-201-T001_1,T4,ALT4532M,
ALT4532M-201-T001_1,T11,ALT4532M,
RJ45_LPJK7001AGNL,J1,LPJK7001AGNL,

## KiCad design DCDCコンバータ24V→5Vver2/降圧チョッパ24V→5V/回路講習用/回路講習用.kicad_pcb

Parts:
C1: 2200uF/50V; CP_Radial_D16.0mm_P7.50mm
C2: 4.7uF/50V; C_0805_2012Metric
C3: 470uF/25V; CP_Radial_D8.0mm_P3.50mm
C4: 1200pF; C_0603_1608Metric
C5: 0.22uF/50V; C_1206_3216Metric
C6: 0.1uF; C_0603_1608Metric
C7: 680pF; C_0603_1608Metric
D1: D_Schottky; D_DO-201AD_P15.24mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
J1: Conn_01x02; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J3: Conn_01x02_Pin; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
L1: 56uH; L_Toroid_Horizontal_D6.5mm_P10.00mm_Diameter7-5mm_Amidon-T25
R1: 39kΩ; R_0603_1608Metric
U1: TO-220F-7_P2.54x3.7mm_StaggerOdd_Lead3.5mm_Vertical

Connections:
GND: C1.2, C2.1, C3.2, C6.2, C7.2, D1.2 (A), J1.1, J3.2, R1.2, U1.4 (GND)
unnamed: C4.2, R1.1
unnamed: C5.2, D1.1 (K), L1.1, U1.2 (SW)
unnamed: C5.1, U1.1 (BS)
unnamed: C4.1, C7.1, U1.5 (COMP)
unnamed: C6.1, U1.7 (EN/SS)
Vin: C1.1, C2.2, J1.2, U1.3 (Vin)
Vo: C3.1, J3.1, L1.2, U1.6 (FB)

Board: 2 copper layers, 52.3 x 47.8 mm, 17 parts (0 on the bottom side), 8 nets.
